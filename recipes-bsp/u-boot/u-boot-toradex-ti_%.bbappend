FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

require u-boot-toradex-raw-flashing.inc
